# Keil uVision project Project.uvprojx, settings and files
target Project-F19 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c main.h project_interrupts.c project_interrupts.h project.h project_images.c project_images.h project_staff.c project_staff.h
  group drivers
    ../drivers/c/: adc.c gpio_port.c timers.c gptimer.c uart.c pc_buffer.c
  group peripherals
    ../peripherals/c/: lcd.c serial_debug.c ps2-new.c
    ../peripherals/include/: ps2.h validate.h
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
